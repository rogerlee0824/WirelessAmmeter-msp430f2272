# IAR project WirelessAmmeter.ewp, settings and files
configuration Ammeter (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F2272 MSP430F2272
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: CONFIG_1; AMMETER
  ICC430.newCCIncludePaths: src\app\; src\Uart\; src\spi\; src\sniff_mode\; src\encryption\
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2272.xcl
  XLINK.XlinkStackSize: 1
configuration Reader (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: CONFIG_1
  ICC430.newCCIncludePaths: src\app\; src\uart\; src\spi\; src\sniff_mode\
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F4152.xcl
  group app
    src/app/: delay.c fbt06.c init.c main_ammeter.c main_reader.c motor.c msp430flash.c updateLCD.c
  group encryption
    src/encryption/: encryption.c md5c.c
  group sniff_mode
    src/sniff_mode/: cc1120_rx_sniff_mode_rx.c cc1120_rx_sniff_mode_tx.c
  group spi
    src/spi/: cc112x_spi.c hal_spi_rf_trxeb.c
  group uart
    src/uart/: Uart.c
